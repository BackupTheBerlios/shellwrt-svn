## trunk/shellwrt/trunk/package/Config.in
```kconfig
config BR2_PACKAGE_SHELLWRT
	tristate "shellwrt - shell interface for OpenWrt"
	default y
	help
	  A shell interface for configuring OpenWrt
```
